VERSION "created by canmatrix"


NS_ :

BS_:

BU_: Host RT MTR SES SEB HMI Any 


BO_ 1 SAFETY_ESTOP_high: 0 Any

BO_ 1 SAFETY_ESTOP_low: 0 Any









