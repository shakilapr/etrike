VERSION "created by canmatrix"


NS_ :

BS_:

BU_: Host RT MTR EPS_C SEB HMI Any 


BO_ 1977 VCU_SEB_REQ_low: 8 RT

BO_ 1825 SEB_STATUS_low: 8 SEB

BO_ 1841 SEB_ERR_INFO_low: 8 SEB

BO_ 1857 SEB_VERSION_low: 8 SEB

BO_ 1787 SEB_TEST_low: 8 SEB





BA_DEF_ BO_ "GenMsgCycleTime" INT 0 65535;


BA_ "GenMsgCycleTime" BO_ 1977 20;
BA_ "GenMsgCycleTime" BO_ 1825 10;
BA_ "GenMsgCycleTime" BO_ 1841 100;
BA_ "GenMsgCycleTime" BO_ 1857 1000;
BA_ "GenMsgCycleTime" BO_ 1787 10;


