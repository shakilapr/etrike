VERSION "created by canmatrix"


NS_ :

BS_:

BU_: Host RT SYS MTR PWT DCDC EPS_C SEB HMI Any 


BO_ 361 VCU_SES_REQ_low: 8 RT

BO_ 513 SES_STATUS_low: 8 EPS_C

BO_ 514 SES_ERR_INFO_low: 8 EPS_C

BO_ 515 SES_VERSION_low: 8 EPS_C

BO_ 1786 SES_TEST_low: 8 EPS_C





BA_DEF_ BO_ "GenMsgCycleTime" INT 0 65535;


BA_ "GenMsgCycleTime" BO_ 361 20;
BA_ "GenMsgCycleTime" BO_ 513 10;
BA_ "GenMsgCycleTime" BO_ 514 100;
BA_ "GenMsgCycleTime" BO_ 515 1000;
BA_ "GenMsgCycleTime" BO_ 1786 10;


